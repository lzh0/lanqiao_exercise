# Keil uVision project e2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: e2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\e2;.\lib
  group Source Group 1
    ./: STARTUP.A51
  group e2
    ./e2/: e2.c
  group lib
    ./lib/: nixietube.c matrixkeyboard.c
